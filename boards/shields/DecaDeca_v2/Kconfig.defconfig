## boards/shields/DecaDeca_v2/Kconfig.defconfig
```kconfig
if SHIELD_DECADECA_V2

config ZMK_KEYBOARD_NAME
    default "DecaDeca_v2"

endif
```
